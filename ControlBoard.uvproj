# Keil uVision project ControlBoard.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ControlBoard +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX
  c include: .\CMSIS\Device\ST;.\CMSIS\Documentation;.\CMSIS\Include;.\FWlib\inc;.\USER;.\ff9
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./USER/: main.c stm32f2xx_it.c adc.c systick.c usart.c fsmc_nand.c crc16.c response.c nand_wr.c led.c MMC_SD.C spi1.c MegDriver.c M41T81.c DHT11.c GPSSource.c adxl345.c wireless.c iwdg.c GPSTIME.c
  group FWlib
    ./FWlib/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_usart.c stm32f2xx_rcc.c stm32f2xx_gpio.c stm32f2xx_fsmc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_exti.c stm32f2xx_tim.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_rtc.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Startup
    ./CMSIS/Device/ST/STM32F2xx/Source/Templates/: startup_stm32f2xx.s
  group ff9
    ./ff9/: diskio.c ff.c
    ./ff9/option/: ccsbcs.c
